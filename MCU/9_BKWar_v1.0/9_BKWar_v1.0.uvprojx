# Keil uVision project 9_BKWar_v1.0.uvprojx, settings and files
target 9_BKWar_v1.0 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 9_BKWar_v1_0 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 wLevel=2
  c include: .\User;..\StdPeriphLib\inc;..\STM32;..\DevLib;..\MATLAB;..\War;..\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Startup/arm/: startup_stm32f10x_md.s
  group MySource
    ./User/: stm32f10x_it.c main.c
  group STM32
    ../STM32/: system_stm32f10x.c
  group StdPeriphLib
    ../StdPeriphLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_can.c
  group DevLib
    ../DevLib/: mcu_board.c sdcard.c utility.c valve.c
  group War
    ../War/: war.c com.c diag.c mem.c
    ../App/: app.c
  group Output
    ./Obj/: 9_BKWar_v1_0.map
software components: CMSIS:CORE 4.3.0
